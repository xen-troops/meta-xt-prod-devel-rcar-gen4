RENESAS_BSP_URL = "git://github.com/renesas-rcar/linux-bsp.git"

BRANCH = "v5.10.41/rcar-5.1.3.rc5"
SRCREV = "3429c829ce579530e9269f63009c5eae199dbd0a"
LINUX_VERSION = "5.10.41"
