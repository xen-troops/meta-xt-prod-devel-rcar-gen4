RENESAS_BSP_URL = " \
    git://github.com/xen-troops/linux.git"
BRANCH = "v5.10.41/rcar-5.1.7.rc2-l3-offload"
SRCREV = "d9150d3add3e3fcae9b35ee5b39f45afea6029d1"
